# IAR project Backup of FRSKYD8(2018-1-23).ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L052R8 STM8L052R8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L05X_HD_VL
  ICCSTM8.CCIncludePath2: LIB\STM8L15x_StdPeriph_Driver\inc; Menu; RF; $PROJ_DIR$
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: FRSKYD8(2018-1-23).bin
  ILINK.IlinkOutputFile: FRSKYD8(2018-1-23).out
  ILINK.IlinkIcfFile: lnkstm8l052r8.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: adc.c beep.c boot.c ee.c key.c LED.c main.c SPI2.c stm8l15x_it.c tbc.c U3.c uniqueID.c
  group LIB
    LIB/STM8L15x_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_dma.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_usart.c
  group MENU
    Menu/: FTDebug.c Menu.c PowerOn.c StartUp.c
  group RF
    RF/: CC2500.c FRSKYD8.c
